# IAR project DIN Rail Meter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F373VB ST STM32F373VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: FAMILY_DIN; ARM_MATH_CM4; FAMILY_LED_DIS
  ICCARM.PreInclude: stm32f37x.h
  ICCARM.CCIncludePath2: ..\Code\Common; ..\Code\System; ..\Code\User; ..\Code\Bootloader
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SOCO Ver1.0.hex
  ILINK.IlinkOutputFile: REX-2551 Ver1.0.out
  ILINK.IlinkIcfFile: ..\Code\Common\Kwh373Meter.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Bootloader
    ../Code/Bootloader/: boot_defs.h boot_main.c boot_vectors.s bootloader.h
  group Common/Inc
    ../Code/Common/: Comm.h CommFlagDef.h CosSinTable.h extern_includes.h I2CDriver.h includes.h ModBus.h modbus_horizon.h stm32f37x_flash.h Struct.h Struct_edit.h
  group Common/Src
    ../Code/Common/: Comm.c DataManagment.c Delay.c EpulseInterrupt.c FlashCoeff.C I2CDriver.c InitMeter.c Interrupt.c Main.c Metrology.c
  group System/Inc
    ../Code/System/: stm32f37x.h
  group System/Src
    ../Code/System/: Clock_DIN.c InterruptHandler_DIN.c startup_stm32f37x.s stm32f37x_flash.c SystemInitialization_DIN.c
  group User/Inc
    ../Code/User/: DIN_MOD_MODEL.h DIN_Struct.h Display_DIN.h EditPara_DIN.h FlagDef_DIN.h fonts_DIN.h Model_DIN.h Parameter_DIN.h
  group User/Src
    ../Code/User/: Display_DIN.c EditPara_DIN.c SetMeterPara_DIN.c
